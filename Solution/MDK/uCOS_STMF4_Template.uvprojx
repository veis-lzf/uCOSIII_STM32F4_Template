# Keil uVision project uCOS_STMF4_Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uCOS_STMF4_Template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP
  c include: ..\..\MCU\MCU_CORE;..\..\MCU\MCU_FWLIB\inc;..\..\MCU\MCU_SYS;..\..\MCU\MCU_BSP\KEY;..\..\MCU\MCU_BSP\LCD;..\..\MCU\MCU_BSP\LED;..\..\MCU\MCU_BSP\RTC;..\..\MCU\MCU_BSP\TIMERS;..\..\MCU\MCU_BSP\USART;..\..\MCU\MCU_BSP;..\..\Libraries\SYSTEM\delay;..\..\Libraries\SYSTEM\sys;..\..\Libraries\USMART;..\..\Micrium\uC-CPU;..\..\Micrium\uC-CPU\ARM-Cortex-M4\RealView;..\..\Micrium\uC-LIB;..\..\Micrium\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\Micrium\uCOSIII\Source;..\..\Micrium\uCOSIII\Ports\ARM-Cortex-M4\Generic\RealView;..\..\UCOS-CONFIG;..\..\uCOS_BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MCU_CORE
    ../../MCU/MCU_CORE/: startup_stm32f40_41xxx.s core_cmInstr.h core_cmFunc.h core_cm4_simd.h core_cm4.h
  group MCU_FWLIB
    ../../MCU/MCU_FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group MCU_SYS
    ../../MCU/MCU_SYS/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group MCU_BSP
    ../../MCU/MCU_BSP/KEY/: BSP_key.c
    ../../MCU/MCU_BSP/LCD/: BSP_LCD.c
    ../../MCU/MCU_BSP/LED/: BSP_LED.c
    ../../MCU/MCU_BSP/RTC/: BSP_RTC.c
    ../../MCU/MCU_BSP/TIMERS/: BSP_TIMERS.c
    ../../MCU/MCU_BSP/USART/: BSP_USART.c
  group Micrium_uC-CPU
    ../../Micrium/uC-CPU/: cpu_core.c
  group Micrium_uC-LIB
    ../../Micrium/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium_uCOSIII
    ../../Micrium/uCOSIII/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group Micrium_Ports
    ../../Micrium/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_c.c cpu_a.asm
    ../../Micrium/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ../../Micrium/uCOSIII/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS_COFG
    ../../UCOS-CONFIG/: os_app_hooks.c
  group uCOS_BSP
    ../../uCOS_BSP/: bsp.c
  group Libraries
    ../../Libraries/SYSTEM/delay/: delay.c
    ../../Libraries/SYSTEM/sys/: sys.c
    ../../Libraries/USMART/: usmart.c usmart_config.c usmart_str.c
  group APP
    ../../APP/src/: main.c
